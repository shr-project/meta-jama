RDEPENDS_${PN}-cli += "\
   packagegroup-jama \
   packagegroup-jama-shr \
"
