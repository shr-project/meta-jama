RDEPENDS_${PN}-cli += "\
   task-jama \
   task-jama-shr \
"
