RDEPENDS_task-core-x11-sato += "task-jama"
