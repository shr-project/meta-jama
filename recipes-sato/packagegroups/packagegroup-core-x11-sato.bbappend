RDEPENDS_packagegroup-core-x11-sato += "packagegroup-jama"
